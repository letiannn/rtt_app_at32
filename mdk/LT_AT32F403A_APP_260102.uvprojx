# Keil uVision project LT_AT32F403A_APP_260102.uvprojx, settings and files
target rt-thread (5060960::V5.06 update 7 (build 960)::.\ARM_COM5)
  device: -AT32F403ARGT7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.1.5
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: app
  AfterMake: fromelf --bin !L --output app.bin
  AfterMake: .\tools\otapack\otapack.bat
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: RT_USING_ARMLIBC, __RTTHREAD__, LFS_CONFIG=lfs_config.h, __CLK_TCK=RT_TICK_PER_SECOND, RT_USING_LIBC, USE_STDPERIPH_DRIVER, __STDC_LIMIT_MACROS, AT32F403AVGT7
  c include: ..\rt-thread\components\dfs\dfs_v1\filesystems\devfs;..\packages\ota_downloader-v1.0.0;..\rt-thread\components\dfs\dfs_v1\include;..\rt-thread\components\libc\compilers\common\extension\fcntl\octal;..\rt-thread\components\drivers\include;..\rt-thread\components\drivers\smp_call;..\rt-thread\components\fal\inc;..\rt-thread\components\drivers\include;..\rt-thread\components\libc\posix\io\epoll;..\rt-thread\components\libc\compilers\common\extension;..\rt-thread\components\drivers\include;..\applications;..\applications\porting\fal;..\packages\CMSIS-Core-latest\Include;..\rt-thread\components\libc\compilers\common\include;..\rt-thread\components\utilities\ymodem;..\board;..\rt-thread\include;..;..\applications\porting\dfs;..\rt-thread\components\drivers\phy;..\rt-thread\libcpu\arm\common;..\rt-thread\components\libc\posix\io\poll;..\rt-thread\components\libc\posix\ipc;..\rt-thread\components\drivers\include;..\rt-thread\components\drivers\include;..\libraries\usbd_library\inc;..\packages\at32f403a_407_cmsis_driver-latest;..\applications\porting\ulog;..\packages\at32f403a_407_hal_driver-latest\inc;..\rt-thread\components\drivers\include;..\packages\FlashDB-v2.1.0\inc;..\packages\CmBacktrace-latest;..\packages\littlefs-v2.11.2;..\rt-thread\components\drivers\include;..\rt-thread\components\utilities\ulog\backend;..\libraries\rt_drivers\config;..\rt-thread\components\drivers\include;..\rt-thread\components\dfs\dfs_v1\filesystems\romfs;..\rt-thread\components\libc\posix\io\eventfd;..\rt-thread\components\libc\posix\io\stdio;..\board\inc;..\rt-thread\components\net\at\include;..\rt-thread\libcpu\arm\cortex-m4;..\packages\syswatch-latest\inc;..\libraries\rt_drivers;..\rt-thread\components\utilities\ulog;..\rt-thread\components\drivers\spi;..\rt-thread\components\drivers\spi\sfud\inc;..\rt-thread\components\net\utest;..\rt-thread\components\finsh
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  scatter file: ..\board\linker_scripts\link.sct
  group Applications
    ../applications/: main.c
  group AT
    ../rt-thread/components/net/at/src/: at_utils.c at_base_cmd.c at_server.c at_cli.c
  group cm_backtrace
    ../packages/CmBacktrace-latest/: cmb_port.c cm_backtrace.c cmb_flash_log.c
  group cmsis
    ../packages/at32f403a_407_cmsis_driver-latest/startup/mdk/: startup_at32f403a_407.s
    ../packages/at32f403a_407_cmsis_driver-latest/: system_at32f403a_407.c
  group Compiler
    ../rt-thread/components/libc/compilers/armlibc/: syscall_mem.c syscalls.c
    ../rt-thread/components/libc/compilers/common/: cctype.c cstdlib.c cstring.c ctime.c cunistd.c cwchar.c
  group DeviceDrivers
    ../rt-thread/components/drivers/core/: device.c
    ../rt-thread/components/drivers/ipc/: completion_comm.c completion_up.c condvar.c dataqueue.c pipe.c ringblk_buf.c ringbuffer.c waitqueue.c workqueue.c
    ../rt-thread/components/drivers/mtd/: mtd_nor.c
    ../rt-thread/components/drivers/pin/: dev_pin.c
    ../rt-thread/components/drivers/serial/: dev_serial.c
    ../rt-thread/components/drivers/spi/: dev_spi.c dev_spi_core.c dev_spi_flash_sfud.c
    ../rt-thread/components/drivers/spi/sfud/src/: sfud.c sfud_sfdp.c
    ../rt-thread/components/drivers/watchdog/: dev_watchdog.c
  group Drivers
    ../board/src/: at32_msp.c board.c
    ../libraries/rt_drivers/: drv_common.c drv_flash.c drv_gpio.c drv_spi.c drv_usart.c drv_wdt.c
  group Fal
    ../rt-thread/components/fal/samples/porting/: fal_flash_sfud_port.c
    ../rt-thread/components/fal/src/: fal_rtt.c fal_flash.c fal.c fal_partition.c
  group Filesystem
    ../rt-thread/components/dfs/dfs_v1/filesystems/devfs/: devfs.c
    ../rt-thread/components/dfs/dfs_v1/filesystems/romfs/: dfs_romfs.c
    ../rt-thread/components/dfs/dfs_v1/src/: dfs.c dfs_file.c dfs_fs.c dfs_posix.c
  group Finsh
    ../rt-thread/components/finsh/: msh_file.c msh_parse.c msh.c shell.c cmd.c
  group FlashDB
    ../packages/FlashDB-v2.1.0/src/: fdb_cmd.c fdb_utils.c fdb_tsdb.c fdb_kvdb.c fdb_file.c fdb.c
  group Kernel
    ../rt-thread/src/: clock.c components.c cpu_up.c defunct.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler_comm.c scheduler_up.c thread.c timer.c
  group klibc
    ../rt-thread/src/klibc/: rt_vsscanf.c kstring.c kerrno.c rt_vsnprintf_std.c kstdio.c
  group libcpu
    ../rt-thread/libcpu/arm/common/: atomic_arm.c div0.c showmem.c
    ../rt-thread/libcpu/arm/cortex-m4/: context_rvds.S cpuport.c
  group libraries
    ../packages/at32f403a_407_hal_driver-latest/src/: at32f403a_407_i2c.c at32f403a_407_wdt.c at32f403a_407_can.c at32f403a_407_dac.c at32f403a_407_gpio.c at32f403a_407_acc.c at32f403a_407_crc.c at32f403a_407_rtc.c at32f403a_407_usb.c at32f403a_407_debug.c at32f403a_407_exint.c at32f403a_407_bpr.c at32f403a_407_emac.c at32f403a_407_wwdt.c at32f403a_407_dma.c at32f403a_407_spi.c at32f403a_407_tmr.c at32f403a_407_crm.c at32f403a_407_xmc.c at32f403a_407_misc.c at32f403a_407_flash.c at32f403a_407_sdio.c at32f403a_407_adc.c at32f403a_407_usart.c at32f403a_407_pwc.c
  group littlefs
    ../packages/littlefs-v2.11.2/: lfs_util.c lfs.c lfs_crc.c dfs_lfs.c
  group ota_downloader
    ../packages/ota_downloader-v1.0.0/src/: ymodem_ota.c
  group port_dfs
    ../applications/porting/dfs/: dfs_cfg.c
  group port_ulog
    ../applications/porting/ulog/: ulog_cfg.c
  group POSIX
    ../rt-thread/components/libc/posix/io/stdio/: stdio.c
  group syswatch
    ../packages/syswatch-latest/src/: syswatch.c syswatch_test.c
  group Utilities
    ../rt-thread/components/utilities/ulog/backend/: console_be.c file_be.c
    ../rt-thread/components/utilities/ulog/: ulog.c
    ../rt-thread/components/utilities/ymodem/: ry_sy.c ymodem.c
